# Keil uVision project STM32F103_FreeRTOS_LED_V1.0.uvprojx, settings and files
target STM32F103_FreeRTOS_LED_V1.0 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB_LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\inc;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./src/: led.c main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: Readme.txt
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
